options:
  parameters:
    generate_options: qt_gui
    id: teste
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200'
  states: {}
- name: ADSB_adsbSingleMsgGen_b_0
  id: ADSB_adsbSingleMsgGen_b
  parameters:
    fixedMsg: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}

connections:
- [ADSB_adsbSingleMsgGen_b_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_vector_sink_x_0, '0']

metadata:
  file_format: 1

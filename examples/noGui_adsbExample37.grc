<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>noGui_adsbExample37</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>ADSB_adsbSingleMsgGen_b</key>
<param><key>id</key><value>ADSB_adsbSingleMsgGen_b_0</value></param>
<param><key>fixedMsg</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>ADSB_adsbSingleMsgGen_b_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
